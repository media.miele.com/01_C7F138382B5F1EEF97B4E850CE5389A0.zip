Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: ea76a075-2a92-4c08-9efe-7d5ff5f19cbe, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-15T10:21:35+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 07222710_GB_B990:13099026_GB_7222710_B990, (2)
In: Default
Type - Material: z_Miele_Design_BRWS, z_Miele_Design_CLST, <Unnamed>, z_Miele_Connection_Connection_Modul, Roller
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 985 mm; Height: 959 mm; Depth: 380 mm
Classification: E1010620 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 13099026_GB_7222710_B990; sets with these values: 2
